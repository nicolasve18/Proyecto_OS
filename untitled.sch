v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {zener.sym} 100 -30 0 0 {name=X1 model=XXX device=XXX}
